## examples/c/hello_world/Kconfig
```kconfig
menu "Hello world"

config HELLO_WORLD_BLINK_MS
    int "How long the LED is on, in milliseconds"
    default 500

endmenu
```
